## up-defconfig
```kconfig
# configs for Up board (based on CHT)

# CONFIG_HZ_1000 is not set
CONFIG_HZ_250=y
CONFIG_HZ=250
```
