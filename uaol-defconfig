## uaol-defconfig
```kconfig
CONFIG_USB_XHCI_HCD=m
CONFIG_USB_XHCI_SIDEBAND=y
CONFIG_SND_USB_OFFLOAD=m
CONFIG_SND_SOC_USB=m
CONFIG_SND_SOC_SOF_INTEL_USB_OFFLOAD=y
```
